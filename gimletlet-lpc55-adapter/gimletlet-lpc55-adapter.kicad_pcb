# Repository oxidecomputer/gemini-bringup

File README.md:

# About
This repository contains the Gemini Bring-up board.

It previous contained many boards which have since been split off into their
own repositories.

## Gemini Bringup Board

Very feature-full board based on the STM32H7. Almost completely retired as of 2023,
but some remain around and functional.

[Subfolder](gemini-bringup)

## KiCad design gimletlet-lpc55-adapter/gimletlet-lpc55-adapter.kicad_pcb

Parts:
C1, C2, C3: 1µF; C_0603_1608Metric; MPN C0603C105K4RAC7867
D1: Green; LED_0603_1608Metric; MPN 150060GS75000
D2: Red; LED_0603_1608Metric; MPN 150060RS75000
D3: Amber; LED_0603_1608Metric; MPN 150060AS75000
H1, H2: M3; MountingHole_3.2mm_M3
H3: GRAPHIC PLACEHOLDER; newt_of_trust
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal; MPN PEC06DGBN
J2: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN FTSH-105-01-F-DV-K
J3: Conn_2Rows-51Pins; DF9-51P-1V; MPN DF9-51P-1V(69)
J4: USART; PinHeader_1x06_P2.54mm_Vertical; MPN PR20206VBNN
J5: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical; MPN PPTC061LFBN-RC
J6: SPI; PinSocket_1x06_P2.54mm_Horizontal; MPN PPPC061LGBN-RC
R1, R2, R3, R7: 143Ω; R_0603_1608Metric; MPN RC0603FR-07143RL
R4, R5: 22Ω; R_0603_1608Metric; MPN RT0603FRE0722RL
R6: MPN RC0603FR-0710KP
SW1: SW_SPST; SW_SPST_PTS810; MPN PTS810 SJS 250 SMTR LFS
SW2: SW_SPDT; SW_SPDT_CK-JS102011SAQN; MPN JS102011SAQN
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Keystone_5015_Micro-Minature; MPN 5015
TP9: TestPoint; MPN 5015
TP10, TP11, TP12, TP13, TP14, TP15: TestPoint; TestPoint_Pad_1.5x1.5mm; MPN 5015

Connections:
+3V3: C1.1, C2.1, C3.1, D1.2 (A), J1.1, J1.2, J2.1 (VTref), J3.44, J3.46, J3.47, J3.48, J3.49, J3.50, J3.51, J5.1, J6.1, R6.2, TP7.1
/FC0_RXD: J3.36, J4.4, TP14.1
/FC0_TXD: J3.40, J4.5, TP15.1
/FC3_CTS_SDAX_SSEL0: J6.6, R7.1
/FC3_RTS_SCLX_SSEL1: J3.28, J5.6, TP9.1
/FC3_RXD_DSA_MOSI: J6.5, R5.1
/FC3_SCK: J6.3, R4.1
/FC3_TXD_SCL_MISO: J3.16, J6.4, TP11.1
/ISP0: J3.3, SW2.2 (B)
/PIO0_4: J3.8, J5.3, TP10.1
/PIO0_22: J3.24, J5.5, TP13.1
/PIO0_25: J3.20, J5.4, TP12.1
/SCT0_OUT2: D2.2 (A), J3.31
/SCT0_OUT3: D3.2 (A), J3.33
/SPI_MISO: J1.7, J3.7, TP3.1
/SPI_MOSI: J1.9, J3.15, TP2.1
/SPI_SCK: J1.5, J3.11, TP4.1
/SWD_CLK: J2.4 (SWDCLK/TCK), J3.39
/SWD_IO: J2.2 (SWDIO/TMS), J3.41
/SWD_TRACESWO: J2.6 (SWO/TDO), J3.37
/~SPI_CS: J1.11, J3.19, R6.1, TP1.1
/~SPI_IRQ: J1.12, J3.23, TP5.1
/~SPI_RESET: J1.10, J3.27, TP6.1
/~SWD_RESET: J2.10 (~RESET), J3.43, SW1.2 (B)
GND: C1.2, C2.2, C3.2, J1.3, J1.4, J2.3 (GND), J2.5 (GND), J2.9 (GNDDetect), J3.1, J3.2, J3.5, J3.6, J3.9, J3.10, J3.13, J3.14, J3.17, J3.18, J3.21, J3.22, J3.25, J3.26, J3.29, J3.30, J3.34, J3.35, J3.38, J3.42, J3.45, J4.1, J5.2, J6.2, R1.1, R2.1, R3.1, SW1.1 (A), SW2.3 (C), TP8.1
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R3.2
unnamed: J3.4, R4.2
unnamed: J3.12, R5.2
unnamed: J3.32, R7.2

Notes on the sheet:
Connection to Gimletlet
RoT reset
RoT SWD
SPI (hackable to SWD)
UART (FTDI)
Debug LEDs
LPC55 Carrier
Boot mode
1-2 Passive Boot 2-3 ISP Boot
Missing CTX/RTX because they're not broken out from the carrier, and 3V3 because this board is powered from the Gimletlet
LPC55 mounting holes
Aux GPIOs
Newt of Trust

Board: 4 copper layers, 55.0 x 79.0 mm, 39 parts (0 on the bottom side), 31 nets.

## KiCad design spimux/spimux.kicad_pcb

Parts:
C1, C2: 10uF; CP_Elec_5x5.3; MPN EDK106M050A9DAA
C3, C4, C5, C6: 1uF; C_0402_1005Metric
H1: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1, J2, J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; MPN PRPC024SAAN-RC
J3: QSPI PMOD; PMOD_12pin_peripheral_horizontal
J4: Connector_Generic_Conn_02x06_Top_Bottom; PinHeader_2x06_P2.54mm_Vertical
J6: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; MPN PRPC024SAAN-RC
R1, R2, R3, R4, R5: 10k; R_0402_1005Metric
U1: LM1117-1.8; SOT-223; MPN LM1117MPX-18NOPB
U2: ADG3308BRUZ; TSSOP-20_4.4x6.5mm_P0.65mm
U3: TS3A27518EPW; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TS3A27518EPWR
U4: MT25QU256ABA8E12; BGA-25_5x5_6.0x8.0mm

Connections:
+1V8: C2.1, C4.1, C5.1, C6.1, J1.1, R2.1, R4.1, R5.1, U1.2 (VO), U2.1 (VCCA), U3.8 (VCC), U4.B4 (VCC)
+3V3: C1.1, C3.1, J3.6, J3.12, J5.1, U1.3 (VI), U2.20 (VCCY)
/FLASH_MUX_SELECT: J6.2, U3.14 (IN2), U3.24 (IN1)
/MANUAL_MUX_SELECT: J5.2, J6.3, R3.1
/SP3_QSPI_CLK: J4.4, U3.16 (NO6)
/SP3_QSPI_IO0: J4.2, U3.17 (NO4)
/SP3_QSPI_IO1: J4.3, U3.15 (NO3)
/SP3_QSPI_IO2: J4.8, U3.13 (NO2)
/SP3_QSPI_IO3: J4.9, U3.11 (NO1)
/SPI_FLASH_CLK: U3.12 (COM6), U4.B2 (C)
/SPI_FLASH_D0: U3.9 (COM4), U4.D3 (DQ0)
/SPI_FLASH_DQ1: U3.7 (COM3), U4.D2 (DQ1)
/SPI_FLASH_DQ2: U3.6 (COM2), U4.C4 (~W~/DQ2)
/SPI_FLASH_DQ3: R4.2, U3.4 (COM1), U4.D4 (DQ3/~HOLD)
/SP_FLASH_CLK_1V8: U2.2 (A1), U3.22 (NC6)
/SP_FLASH_DQ0_1V8: U2.5 (A4), U3.21 (NC4)
/SP_FLASH_DQ1_1V8: U2.6 (A5), U3.23 (NC3)
/SP_FLASH_DQ2_1V8: U2.7 (A6), U3.1 (NC2)
/SP_FLASH_DQ3_1V8: U2.8 (A7), U3.2 (NC1)
/SP_QSPI_CLK: J3.4, U2.19 (Y1)
/SP_QSPI_IO0: J3.2, U2.16 (Y4)
/SP_QSPI_IO1: J3.3, U2.15 (Y5)
/SP_QSPI_IO2: J3.8, U2.14 (Y6)
/SP_QSPI_IO3: J3.9, U2.13 (Y7)
/SP_QSPI_XTRA7: J3.7, U2.18 (Y2)
/SP_QSPI_XTRA10: J3.10, J6.1
/SP_TRANS_EN: J2.1, R2.2, U2.10 (EN)
/~SP3_QSPI_CS: J4.1, U3.18 (NO5)
/~SPI_FLASH_CS_L: U3.10 (COM5), U4.C2 (~S)
/~SPI_MUX_EN_L: J1.2, R1.1, U3.20 (~EN)
/~SP_FLASH_CS_L_1V8: U2.4 (A3), U3.19 (NC5)
/~SP_FLASH_RESET_L_1V8: R5.2, U2.3 (A2), U4.A4 (~RESET)
/~SP_QSPI_CS: J3.1, U2.17 (Y3)
GNDREF: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, H1.1, J2.2, J3.5, J3.11, J4.6, J4.12, R1.2, R3.2, U1.1 (GND), U2.11 (GND), U3.5 (GND), U4.B3 (VSS)

Notes on the sheet:
QSPI Mux: NC=SP connection (IN1 + IN2 Low) NO=SP3 connection (IN1 + IN2 High)
Decoupling for Mux and Flash
Decoupling for ADG330BBCPZ
Matches gimletlet QSPI Header. XTRA7 is ~FLASH_RESET_L XTRA10 is SP_FLASH_MUX_SELECT
Install jumper to disable SPI_MUX outputs. Use dupont wire on pin2 for for ~MUX_EN_L~ control
Install jumper to disable SPI Level translator outputs. Use dupont wire on pin1 for for SP_TRANS_EN control
Dupont header for connection to an SP3 dev system. Pin-out kept consistent with the Qspi but expects 1V8 voltage levels here
SP Connection
AMD (SP3) Connection
Manual Override Headers
Generate 1V8 from SP header's 3V3 input using an LDO
Install Jumper to force Mux to AMD (SP3) but only if J6 is Jumpered between pins 2 and 3 also.
Jumper required! Install between Pins 1 and 2 for SP mux control Install between Pins 2 and 3 for J5 jumper control
(~SP_FLASH_RESET_L)

Board: 2 copper layers, 75.0 x 20.0 mm, 22 parts (1 on the bottom side), 34 nets.

## KiCad design ignition_adafruit_ft232h_rD_adapter.kicad_pcb

Schematic: ignition_adafruit_ft232h_rD_adapter.sch, Ignition Header Adapter for Adafruit FT232H rev D

Parts:
FID1, FID3: Fiducial; Fiducial_0.5mm_Mask1mm
FID2: iCE40 Adapter; Oxide_Board_Identifier_23x6mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_100mils_Pad
J1: ADAFRUIT_FT232H_REV_D; ADAFRUIT_FT232H_REVD
J2: IGNITION_TARGET_HDR; TFC-105-02-F-D-A-K
JP1: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm
R1, R2: 22; R_0603_1608Metric

Connections:
/CDONE: J1.10, J2.7 (CDONE)
/SPI_MISO: J1.6, J2.3 (MISO)
/SPI_MOSI: J2.2 (MOSI), R2.2
/SPI_SCK: J2.4 (SCK), R1.2
/VCC: J2.6 (VCC_3V), JP1.2 (C)
/~CRESET: J1.11, J2.8 (~RESET)
/~SPI_SS: J1.8, J2.1 (~SS)
GND: H1.1, H2.1, H3.1, H4.1, J1.3, J1.22, J2.5 (GND)
unnamed: J1.1, JP1.1 (A)
unnamed: J1.2, JP1.3 (B)
unnamed: J1.4, R1.1
unnamed: J1.5, R2.1

Notes on the sheet:
SPI pinout does not follow Tabel 3.10 in the FT232HQ datasheet but instead replicate the snippet below, found on the Lattice iCEstick Evaluation Kit. This will preserve compatibility with existing programming tools.

Board: 4 copper layers, 48.3 x 22.9 mm, 12 parts (2 on the bottom side), 12 nets.

## KiCad design lvds_sma_adapter.kicad_pcb

Parts:
C1, C2, C3, C4: GCM188R71E105KA64D; C_0603_1608Metric
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
FID3: LVDS Adapter; Oxide_Board_Identifier_23x6mm
J1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Horizontal
J2, J3, J4, J5, J6, J7, J8, J9: Conn_Coaxial; SMA_Amphenol_132134-16_Vertical
L1, L2: MCZ1210AH900L2TA0G; L_Choke_MCZ1210AH

Connections:
/AUX0_RX_N: C2.2, J1.9
/AUX0_RX_P: C1.2, J1.10
/AUX0_TX_N: J1.5, L1.2
/AUX0_TX_P: J1.6, L1.1
/AUX1_RX_N: C4.2, J1.17
/AUX1_RX_P: C3.2, J1.18
/AUX1_TX_N: J1.13, L2.1
/AUX1_TX_P: J1.14, L2.2
GND: J1.3, J1.4, J1.7, J1.8, J1.11, J1.12, J1.15, J1.16, J1.19, J1.20, J1.23, J1.24, J1.27, J1.28, J1.31, J1.32, J1.35, J1.36, J2.2 (Ext), J3.2 (Ext), J4.2 (Ext), J5.2 (Ext), J6.2 (Ext), J7.2 (Ext), J8.2 (Ext), J9.2 (Ext)
unnamed: C1.1, J2.1 (In)
unnamed: C2.1, J3.1 (In)
unnamed: C3.1, J4.1 (In)
unnamed: C4.1, J5.1 (In)
unnamed: J6.1 (In), L1.4
unnamed: J7.1 (In), L1.3
unnamed: J8.1 (In), L2.4
unnamed: J9.1 (In), L2.3

Board: 4 copper layers, 53.3 x 31.8 mm, 18 parts (1 on the bottom side), 17 nets.

## KiCad design gimletlet-2/gimletlet.kicad_pcb

Schematic: gimletlet.sch, Gimlet-let addon thingy

Parts:
C1, C2: 22µ; CP_EIA-7343-31_Kemet-D; MPN T491D226K020AT7280
C3, C4: 11p; C_0603_1608Metric; MPN C0603C110J5GACTU
C5, C6: 2µ2 100mR; C_0603_1608Metric; MPN C0603C225K4PACTU
C7: 4µ7; C_0603_1608Metric; MPN CL10A475KQ8NNNC
C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20: 0µ1; C_0603_1608Metric; MPN C0603C104M4RACTU
D1: LED; LED_0603_1608Metric; MPN 150060RS75000
D2: LED; LED_0603_1608Metric; MPN 150060AS75000
D3: LED; LED_0603_1608Metric; MPN 150060GS75000
D4: LED; LED_0603_1608Metric; MPN 150060BS75000
F1: Polyfuse; Fuse_1812_4532Metric; MPN 1812L200/16DR
FID1: LOLNO; Oxide_Board_Identifier_33x7mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: BarrelJack; BarrelJack_CUI_PJ-036AH-SMT_Horizontal; MPN PJ-036AH-SMT-TR
J2, J3, J4, J5: Conn6x2; PMOD_12pin_host_horizontal; MPN PPTC062LJBN-RC
J6: Conn41x2; Hirose_DF9-41S-1V(69)_2Rows_41Pin-2MP_P1.0mm_Vertical; MPN DF9-41S-1V(32)
J7, J8: Conn3x2; PinSocket_2x03_P2.54mm_Vertical; MPN RS2-06-G
J9, J10, J11, J12, J13, J14: Conn6x1; PMOD_6pin_host_horizontal; MPN FR20206HBNN
J15: SWD; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN FTSH-105-01-F-DV-K
J16: Conn9x1; PinSocket_1x09_P2.54mm_Vertical; MPN RS1-09-G
J17: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical; MPN RS1-07-G
JP1, JP2: Conn2x1; PinHeader_1x02_P2.54mm_Vertical; MPN PH1-02-UA
JP3: Conn2x1; PinHeader_2x01_P2.54mm_Vertical; MPN PH1-02-UA
R1, R2, R3, R5, R6, R7, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R38, R52: 10k; R_0603_1608Metric; MPN CR0603-JW-103ELF
R4, R8: 100k; R_0603_1608Metric; MPN CR0603-JW-104ELF
R31, R32, R33, R34, R35, R36, R37, R39, R40, R41, R42, R43, R44, R45, R46, R47: 22; R_0603_1608Metric; MPN CR0603-JW-220ELF
R48, R49, R50, R51: 68; R_0603_1608Metric; MPN CR0603-JW-680ELF
SW1: Button; PTS815; MPN PTS815 SJM 250 SMTR LFS
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11: TestPoint_Small; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23: TestPoint; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded; MPN 5006
U1: OKI-78SR-3.3_1.5-W36-C; Converter_DCDC_muRata_OKI-78SR_Vertical; MPN OKI-78SR-3.3/1.5-W36-C
U2: STM32H753ZITx; LQFP-144_20x20mm_P0.5mm; MPN STM32H753ZIT6
Y1: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm; MPN ECS-80-12-30Q-DS-TR

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, J2.6, J2.12, J3.6, J3.12, J4.6, J4.12, J5.6, J5.12, J6.19, J6.21, J6.23, J6.33, J6.35, J6.37, J8.1, J8.3, J8.5, J9.6, J10.6, J11.6, J12.6, J13.6, J14.6, J15.1 (VTref), J16.1, J17.1, JP2.2, JP3.1 (A), R1.2, R2.2, R3.2, R4.1, R5.2, R6.2, R7.2, R8.1, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R38.2, U2.6, U2.17, U2.30, U2.32, U2.33, U2.39, U2.52, U2.62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
+12V: C1.1, F1.1, J7.1, J7.3, J7.5, U1.1 (IN)
/12V_IN: F1.2, JP1.2
/BOOT0: JP3.2 (B), R52.1, U2.138
/I2C2_SCL: J9.3, R25.1, U2.11
/I2C2_SDA: J9.4, R28.1, U2.10
/I2C3_SCL: J10.3, R26.1, U2.100
/I2C3_SDA: J10.4, R29.1, U2.99
/I2C4_SCL: J6.22, J11.3, R27.1, U2.54
/I2C4_SDA: J6.24, J11.4, R30.1, U2.55
/JACK_12V: J1.1, JP1.1
/LED0: R48.2, U2.87
/LED1: R49.2, U2.88
/LED2: R50.2, U2.89
/LED3: R51.2, U2.90
/MDC: J6.3, R4.2, R44.2, TP1.1
/MDIO: J6.5, R41.2, TP2.1
/OSC_IN: C3.1, U2.23, Y1.2
/OSC_OUT: C4.1, U2.24, Y1.1
/PB0: J6.13, U2.46
/PB1: J6.14, U2.47
/PB2: J6.15, U2.48
/PB14: J16.2, U2.75
/PB15: J16.3, U2.76
/PD8: J16.4, U2.77
/PD9: J16.5, U2.78
/PD10: J16.6, U2.79
/PD11: J16.7, U2.80
/PD12: J16.8, U2.81
/PE2: J17.2, U2.1
/PE3: J17.3, U2.2
/PE4: J17.4, U2.3
/PE5: J17.5, U2.4
/PE6: J17.6, U2.5
/PF11: J6.16, U2.49
/PF12: J6.17, U2.50
/QSPI_CLK: J2.4, R37.2
/QSPI_IO0: J2.2, R35.2
/QSPI_IO1: J2.3, R36.2
/QSPI_IO2: J2.8, R34.2
/QSPI_IO3: J2.9, R33.2
/QSPI_XTRA7: J2.7, U2.14
/QSPI_XTRA10: J2.10, U2.15
/REG_3V3: C2.1, JP2.1, U1.3 (OUT)
/RMII_CRS_DV: J6.6, TP9.1, U2.43
/RMII_REF_CLK: J6.2, TP8.1, U2.35
/RMII_RXD0: J6.8, TP10.1, U2.44
/RMII_RXD1: J6.10, TP11.1, U2.45
/RMII_TXD0: J6.38, R47.1, TP6.1
/RMII_TXD1: J6.40, R43.1, TP7.1
/RMII_TXEN: J6.36, R42.1, TP5.1
/SPI3_MISO: J3.3, R5.1, U2.112
/SPI3_MOSI: J3.2, R46.1
/SPI3_SCK: J3.4, R10.1, R45.1
/SPI4_MISO: J4.3, J6.30, R6.1, R40.2
/SPI4_MOSI: J4.2, J6.32, U2.67
/SPI4_SCK: J4.4, J6.28, R11.1, R32.2
/SPI6_MISO: J5.3, R7.1, U2.127
/SPI6_MOSI: J5.2, R39.2
/SPI6_SCK: J5.4, R12.1, R31.2
/SWCLK: J15.4 (SWDCLK/TCK), U2.109
/SWDIO: J15.2 (SWDIO/TMS), U2.105
/SWO: J15.6 (SWO/TDO), U2.133
/UART7_CTS: J14.1, U2.63
/UART7_RTS: J14.4, U2.60
/UART7_RX: J14.3, U2.58
/UART7_TX: J14.2, U2.59
/USART1_CTS: J12.1, U2.103
/USART1_RTS: J12.4, U2.104
/USART1_RX: J12.3, U2.137
/USART1_TX: J12.2, U2.136
/USART2_CTS: J13.1, U2.117
/USART2_RTS: J13.4, U2.118
/USART2_RX: J13.3, U2.122
/USART2_TX: J13.2, U2.119
/~I2C2_RESET: J9.2, R22.1, U2.13
/~I2C2_SMBA: J9.1, R19.1, U2.12
/~I2C3_RESET: J10.2, R23.1, U2.102
/~I2C3_SMBA: J10.1, R20.1, U2.101
/~I2C4_RESET: J11.2, R24.1, U2.56
/~I2C4_SMBA: J6.20, J11.1, R21.1, U2.53
/~QSPI_CS: J2.1, R9.1, U2.91
/~RST: C20.1, J15.10 (~RESET~), SW1.1, U2.25
/~SMI_IRQ: J6.7, R8.2, TP3.1, U2.26
/~SMI_RESET: J6.9, TP4.1, U2.41
/~SPI3_CS: J3.1, R1.1, U2.110
/~SPI3_INT: J3.7, R13.1, U2.114
/~SPI3_RESET: J3.8, R16.1, U2.115
/~SPI4_CS: J4.1, J6.27, R2.1, U2.64
/~SPI4_INT: J4.7, J6.29, R14.1, U2.68
/~SPI4_RESET: J4.8, J6.31, R17.1, U2.69
/~SPI6_CS: J5.1, R3.1, U2.93
/~SPI6_INT: J5.7, R15.1, U2.126
/~SPI6_RESET: J5.8, R18.1, U2.132
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), H1.1, H2.1, H3.1, H4.1, J1.2, J2.5, J2.11, J3.5, J3.11, J4.5, J4.11, J5.5, J5.11, J6.1, J6.4, J6.11, J6.12, J6.18, J6.25, J6.26, J6.34, J6.39, J6.41, J7.2, J7.4, J7.6, J8.2, J8.4, J8.6, J9.5, J10.5, J11.5, J12.5, J13.5, J14.5, J15.3 (GND), J15.5 (GND), J15.9 (GNDDetect), J16.9, J17.7, R52.2, SW1.2, TP12.1, TP13.1, TP14.1, TP15.1, TP16.1, TP17.1, TP18.1, TP19.1, TP20.1, TP21.1, TP22.1, TP23.1, U1.2 (GND), U2.16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
unnamed: C5.1, C6.1, U2.71, U2.106
unnamed: D1.2 (A), R48.1
unnamed: D2.2 (A), R49.1
unnamed: D3.2 (A), R50.1
unnamed: D4.2 (A), R51.1
unnamed: R31.1, U2.128
unnamed: R32.1, U2.65
unnamed: R33.1, U2.18
unnamed: R34.1, U2.19
unnamed: R35.1, U2.20
unnamed: R36.1, U2.21
unnamed: R37.1, U2.22
unnamed: R38.1, U2.143
unnamed: R39.1, U2.129
unnamed: R40.1, U2.66
unnamed: R41.1, U2.36
unnamed: R42.2, U2.70
unnamed: R43.2, U2.74
unnamed: R44.1, U2.27
unnamed: R45.2, U2.111
unnamed: R46.2, U2.113
unnamed: R47.2, U2.73

Notes on the sheet:
Interfaces routed:
QSPI: CLK=F10 IO{3,2,0,1}=F6-9 ~CS=G6
I2C2: SDA=F0 SCL=F1 ~SMBA=F2
I2C4: SDA=F15, SCL=F14, ~SMBA=F13
USART1: TX=B6 RX=B7 RTS=A12 CTS=A11
SPI6: MISO=G12 MOSI=G14 SCK=G13 CS=G8
SPI4: MISO=E13 MOSI=E14 SCK=E12 ~CS=E11
SPI3: MISO=C11 MOSI=C12 SCK=C10 ~CS=A15
I2C3: SDA=C9 SCL=A8 ~SMBA=A9
USART2: TX=D5 RX=D6 CTS=D3 RTS=D4
UART7: TX=E8 RX=E7 RTS=E9 CTS=E10
JP1 allows power injection upstream from fuse.
JP2 allows disconnection of power supply or 3v3 injection.
SPI (PMOD type 2A)
INT and RESET lines can also act as extra chip selects.
I²C (PMOD type 6)
REMOVE DEVICE PULLUP JUMPERS
General notes:
Slew-limiting resistors placed near the driver.
Pull resistors provided and placed near primary connector.
Qwiic/Grove/Stemma/QT connectors can be jumpered to the 100mil PMOD headers.
For dupont wires →
SHARED WITH NIC!
ALL I/O 3.3V.
Probing SPI? Use J4.
Probing I²C? Use J11.
Test points placed near primary connector.
UART (PMOD type 3)
QUADSPI
NIC RMII+SPI+I2C
POWER
PROGRAM/DEBUG
HACKING

Board: 4 copper layers, 99.7 x 103.5 mm, 131 parts (14 on the bottom side), 117 nets.
