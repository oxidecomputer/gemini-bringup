# Repository oxidecomputer/gemini-bringup (continued)

## KiCad design mgmt-bringup/gimlet-mgmt-bringup.kicad_pcb

Schematic: gimlet-mgmt-bringup.sch, Gimlet Management Network Bringup

Parts:
C101, C102, C103, C104, C105, C106, C107: 0.1u; C_0603_1608Metric; MPN C0603C104K4PACTU
C108: 22u; CP_EIA-7343-31_Kemet-D; MPN T491D226K025AT
FID101, FID102, FID103, FID104, FID105, FID106: Fiducial; Fiducial_1mm_Mask2mm
G101: 230-0000003; Oxide_Board_Identifier_28x7mm
H101, H102, H103, H104: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J101, J102, J103, J104, J107, J109, J110, J112: Conn_Coaxial; SMA_Amphenol_901-144_Vertical; MPN 901-144-8RFX
J105: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical; MPN 77313-118-30LF
J106: SFF-8087_miniSAS; SAS-mini_TEConnectivity_1888019_RightAngle; MPN 1888019-4
J108: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; MPN 77311-118-03LF
J111: Conn_02x16_Odd_Even; PinHeader_2x16_P2.54mm_Vertical; MPN 77313-118-32LF
J113: Barrel_Jack; BarrelJack_Wuerth_6941xx301002; MPN 694106301002
R101, R102, R103, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120: 10k; R_0603_1608Metric; MPN CR0603-JW-103ELF
R104: 2k; R_0603_1608Metric; MPN CR0603-FX-2001ELF
TP101, TP102, TP103, TP104, TP105, TP106, TP107, TP108, TP109, TP110, TP111, TP112, TP113, TP114, TP115, TP116, TP117, TP118, TP119, TP120, TP121, TP122, TP123, TP124, TP125, TP126, TP127, TP128, TP129, TP130, TP131, TP132, TP133, TP134, TP135, TP136, TP137, TP138, TP139, TP140, TP141: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U101: SN74AXC4T774PW; TSSOP-16_4.4x5mm_P0.65mm; MPN SN74AXC4T774PWR
U102, U104: SN74AXC8T245PW; TSSOP-24_4.4x7.8mm_P0.65mm; MPN SN74AXC8T245PWR
U103: PCA9555DB; SSOP-24_5.3x8.2mm_P0.65mm; MPN PCA9555DBR

Connections:
+3V3: J108.1, J111.1, J111.3; also elsewhere on the board
/3V3_EXT: J108.3, J111.2, J111.4
/3V3_SHIFT: C102.1, C105.1, C107.1, J108.2, R103.1, R119.1, U101.16, U102.1, U104.1
/A0: R114.2, R117.2, U103.21
/A1: R113.2, R116.2, U103.2
/A2: R112.2, R115.2, U103.3
/AUX0_RX_N: J112.1 (In); also elsewhere on the board
/AUX0_RX_P: J110.1 (In); also elsewhere on the board
/AUX0_TX_N: J109.1 (In); also elsewhere on the board
/AUX0_TX_P: J107.1 (In); also elsewhere on the board
/AUX1_RX_N: J106.A17; also elsewhere on the board
/AUX1_RX_P: J106.A16; also elsewhere on the board
/AUX1_TX_N: J106.B17; also elsewhere on the board
/AUX1_TX_P: J106.B16; also elsewhere on the board
/AUX_CMD0: U102.21, U103.4; also elsewhere on the board
/AUX_CMD0_SHIFTED: J111.5, U102.3
/AUX_CMD1: U102.20, U103.5; also elsewhere on the board
/AUX_CMD1_SHIFTED: J111.6, U102.4
/AUX_CMD2: U102.19, U103.6; also elsewhere on the board
/AUX_CMD2_SHIFTED: J111.7, U102.5
/AUX_CMD3: U102.18, U103.7; also elsewhere on the board
/AUX_CMD3_SHIFTED: J111.8, U102.6
/AUX_CMD4: U102.17, U103.8; also elsewhere on the board
/AUX_CMD4_SHIFTED: J111.9, U102.7
/AUX_CMD5: U102.16, U103.9; also elsewhere on the board
/AUX_CMD5_SHIFTED: J111.10, U102.8
/AUX_CMD6: U102.15, U103.10; also elsewhere on the board
/AUX_CMD6_SHIFTED: J111.11, U102.9
/AUX_CMD7: U102.14, U103.11; also elsewhere on the board
/AUX_CMD7_SHIFTED: J111.12, U102.10
/AUX_I2C_SCL: J111.21, R107.2, U103.22
/AUX_I2C_SDA: J111.23, R108.2, U103.23
/AUX_SPI_CIPO: U101.11; also elsewhere on the board
/AUX_SPI_CIPO_SHIFTED: J111.31, U101.6
/AUX_SPI_COPI: U101.12; also elsewhere on the board
/AUX_SPI_COPI_SHIFTED: J111.29, U101.5
/AUX_SPI_SCK: U101.14; also elsewhere on the board
/AUX_SPI_SCK_SHIFTED: J111.25, U101.3
/AUX_STATUS0: U103.13, U104.21; also elsewhere on the board
/AUX_STATUS0_SHIFTED: J111.13, U104.3
/AUX_STATUS1: U103.14, U104.20; also elsewhere on the board
/AUX_STATUS1_SHIFTED: J111.14, U104.4
/AUX_STATUS2: U103.15, U104.19; also elsewhere on the board
/AUX_STATUS2_SHIFTED: J111.15, U104.5
/AUX_STATUS3: U103.16, U104.18; also elsewhere on the board
/AUX_STATUS3_SHIFTED: J111.16, U104.6
/AUX_STATUS4: U103.17, U104.17; also elsewhere on the board
/AUX_STATUS4_SHIFTED: J111.17, U104.7
/AUX_STATUS5: U103.18, U104.16; also elsewhere on the board
/AUX_STATUS5_SHIFTED: J111.18, U104.8
/AUX_STATUS6: U103.19, U104.15; also elsewhere on the board
/AUX_STATUS6_SHIFTED: J111.19, U104.9
/AUX_STATUS7: U103.20, U104.14; also elsewhere on the board
/AUX_STATUS7_SHIFTED: J111.20, U104.10
/Power Regulation/3V3_PGOOD: TP141.1; also elsewhere on the board
/Power Regulation/12V: C108.1, J113.1, R120.1; also elsewhere on the board
/Power Regulation/PWR_EN: R120.2, TP140.1; also elsewhere on the board
/RMII_CRS_DV: J105.11; also elsewhere on the board
/RMII_REF_CLK: J105.13; also elsewhere on the board
/RMII_RXD0: J105.7; also elsewhere on the board
/RMII_RXD1: J105.9; also elsewhere on the board
/RMII_TXD0: J105.15; also elsewhere on the board
/RMII_TXD1: J105.17; also elsewhere on the board
/RMII_TX_EN: J105.19; also elsewhere on the board
/SGMII0_RX_N: J106.A3; also elsewhere on the board
/SGMII0_RX_P: J106.A2; also elsewhere on the board
/SGMII0_TX_N: J106.B3; also elsewhere on the board
/SGMII0_TX_P: J106.B2; also elsewhere on the board
/SGMII1_RX_N: J104.1 (In); also elsewhere on the board
/SGMII1_RX_P: J103.1 (In); also elsewhere on the board
/SGMII1_TX_N: J102.1 (In); also elsewhere on the board
/SGMII1_TX_P: J101.1 (In); also elsewhere on the board
/SMI_MDC: J105.3; also elsewhere on the board
/SMI_MDIO: J105.1, R104.2; also elsewhere on the board
/SPI_DI: J105.25; also elsewhere on the board
/SPI_DO: J105.29; also elsewhere on the board
/SPI_SCLK: J105.23; also elsewhere on the board
/dual_sgmii_phy/COMA_MODE: TP114.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO0: TP101.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO1: TP102.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO4: TP103.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO5: TP104.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO8: TP106.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO9: TP109.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO10: TP113.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO11: TP117.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO12: TP120.1; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO13: TP125.1; also elsewhere on the board
/dual_sgmii_phy/RCVRDCLK1: TP134.1; also elsewhere on the board
/dual_sgmii_phy/RCVRDCLK2: TP135.1; also elsewhere on the board
/dual_sgmii_phy/TCK: TP131.1; also elsewhere on the board
/dual_sgmii_phy/TDI: TP126.1; also elsewhere on the board
/dual_sgmii_phy/TDO: TP128.1; also elsewhere on the board
/dual_sgmii_phy/TMS: TP121.1; also elsewhere on the board
/dual_sgmii_phy/TRST: TP132.1; also elsewhere on the board
/dual_sgmii_phy/~PHY_RST: TP133.1; also elsewhere on the board
/ethernet_switch/SW_GPIO0: TP105.1; also elsewhere on the board
/ethernet_switch/SW_GPIO1: TP107.1; also elsewhere on the board
/ethernet_switch/SW_GPIO2: TP110.1; also elsewhere on the board
/ethernet_switch/SW_GPIO3: TP115.1; also elsewhere on the board
/ethernet_switch/SW_GPIO4: TP118.1; also elsewhere on the board
/ethernet_switch/SW_GPIO5: TP122.1; also elsewhere on the board
/ethernet_switch/SW_GPIO6: TP111.1; also elsewhere on the board
/ethernet_switch/SW_GPIO7: TP116.1; also elsewhere on the board
/ethernet_switch/SW_GPIO8: TP119.1; also elsewhere on the board
/ethernet_switch/SW_GPIO9: TP123.1; also elsewhere on the board
/ethernet_switch/SW_GPIO10: TP127.1; also elsewhere on the board
/ethernet_switch/SW_GPIO11: TP130.1; also elsewhere on the board
/ethernet_switch/~SW_RST: TP129.1; also elsewhere on the board
/~AUX_I2C_INT: J111.22, R109.2, U103.1
/~AUX_SPI_CS: U101.13; also elsewhere on the board
/~AUX_SPI_CS_SHIFTED: J111.27, U101.4
/~SMI_INTR: J105.5, R105.2, R106.2; also elsewhere on the board
/~SPI_CS: J105.27; also elsewhere on the board
/~SW_INTR: J105.21; also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, H101.1, H102.1, H103.1, H104.1, J101.2 (Ext), J102.2 (Ext), J103.2 (Ext), J104.2 (Ext), J105.2, J105.4, J105.6, J105.8, J105.10, J105.12, J105.14, J105.16, J105.18, J105.20, J105.22, J105.24, J105.26, J105.28, J105.30, J106.A1, J106.A4, J106.A7, J106.A12, J106.A15, J106.A18, J106.B1, J106.B4, J106.B7, J106.B12, J106.B15, J106.B18, J107.2 (Ext), J109.2 (Ext), J110.2 (Ext), J111.24, J111.26, J111.28, J111.30, J111.32, J112.2 (Ext), J113.2, R101.1, R102.1, R106.1, R110.1, R111.1, R115.1, R116.1, R117.1, R118.1, U101.10, U102.11, U102.12, U102.13, U103.12, U104.11, U104.12, U104.13; also elsewhere on the board
unnamed: R101.2, TP108.1, U101.9
unnamed: R102.2, TP124.1, U101.8
unnamed: R103.2, TP112.1, U101.1, U101.2, U101.7
unnamed: R110.2, TP136.1, U102.22
unnamed: R111.2, TP137.1, U102.2
unnamed: R118.2, TP138.1, U104.22
unnamed: R119.2, TP139.1, U104.2

Notes on the sheet:
Stagger grounds for IDC ribbon - done
Drop GPIO from miniSAS, add I2C - done
Configure MDIO for open-drain operation
TODO MPN for jumper

Schematic: power_regulation.sch, Gimlet Management Network Bringup

Parts:
C201: 22u; C_1210_3225Metric; MPN C1210C226K4PACTU
C202, C203, C204, C208: 1u; C_0805_2012Metric; MPN C0805C105K3RACTU
C205, C209: 1u; C_0603_1608Metric; MPN C0603C105K4PACTU
C206: 22u; CP_EIA-7343-31_Kemet-D; MPN T491D226K025AT
C207: 430p; C_0603_1608Metric; MPN C0603C431J5GACTU
R201, R203, R205: 100k; R_0603_1608Metric; MPN CR0603-FX-1003ELF
R202: 309k; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-3093ELF
R204: 100k; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-1003ELF
U201: TLV75725PDBV; SOT-23-5; MPN TLV75725PDBVR
U202: TLV75710PDRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TLV75710PDRVR
U203: TPS82140; Texas_SIL0008D_MicroSiP-8-1EP_2.8x3mm_P0.65mm_EP1.1x1.9mm_T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; MPN TPS82140SILR
U204: TLV70012_SOT353; SOT-353_SC-70-5; MPN TLV70012DCKR

Connections:
+3V3: C201.1, C202.1, R202.1, R203.1, U201.1, U203.4, U203.5; also elsewhere on the board
/Power Regulation/1V2_EN: R205.2, U204.3
/Power Regulation/1V_EN: R201.2, U202.4
/Power Regulation/3V3_FB: R202.2, R204.1, U203.6
/Power Regulation/3V3_PGOOD: R203.2, U201.3, U203.7; also elsewhere on the board
/Power Regulation/3V3_SS: C207.1, U203.8
/Power Regulation/12V: C206.1, U203.2; also elsewhere on the board
/Power Regulation/PWR_EN: U203.1; also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, R204.2, U201.2, U202.3, U202.7, U203.3, U203.9, U204.2; also elsewhere on the board

Notes on the sheet:
Vout = Vfb * (1 + R1/R2) Vfb (min, max) = (785, 823) mV R1 (min, max) = (305.91, 312.09) kOhm R2 (min, max) = (99, 101) kOhm Vout (min, max) = (3.163, 3.417) V Vout acceptable range = (3.135, 3.465) V Ifb neglected
215 usec rise time
2% accuracy Vout (min, max) = (1.176, 1.224) V Vout acceptable range = (1.140, 1.260) V
1% accuracy Vout (min, max) = (0.990, 1.010) V Vout acceptable range = (0.950, 1.050) V
1% accuracy Vout (min, max) = (2.475, 2.525) V Vout acceptable range = (2.375, 2.625) V

Parts:
R301, R302, R308, R309, R315, R316, R322, R323: 0R; R_0603_1608Metric; MPN CR0603-J/-000ELF
R303, R304, R312, R313, R317, R318, R326, R327: 200R; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-2000ELF
R305, R306, R310, R311, R319, R320, R324, R325: 49R9; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-49R9ELF
R307, R314, R321, R328: 18R; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-18R0ELF

Connections:
/BaseFX_Termination/PORT0_PHY_RX_N: R309.1, R310.1; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_RX_P: R308.1, R311.1; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_TX_N: R302.2, R303.1; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_TX_P: R301.1, R304.1; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_RX_N: R302.1, R306.1; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_RX_P: R301.2, R305.1; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_TX_N: R309.2, R313.1; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_TX_P: R308.2, R312.1; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_RX_N: R323.1, R324.1; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_RX_P: R322.1, R325.1; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_TX_N: R316.1, R317.1; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_TX_P: R315.1, R318.1; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_RX_N: R316.2, R320.1; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_RX_P: R315.2, R319.1; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_TX_N: R323.2, R327.1; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_TX_P: R322.2, R326.1; also elsewhere on the board
GND: R303.2, R304.2, R307.2, R312.2, R313.2, R314.2, R317.2, R318.2, R321.2, R326.2, R327.2, R328.2; also elsewhere on the board
unnamed: R305.2, R306.2, R307.1
unnamed: R310.2, R311.2, R314.1
unnamed: R319.2, R320.2, R321.1
unnamed: R324.2, R325.2, R328.1

Notes on the sheet:
100nF per Micrel WP

Schematic: aux_controller.sch, Gimlet Management Network Bringup

Parts:
C401, C402, C403, C404, C405, C407, C408, C409, C410, C411, C412, C413, C414, C415, C416, C417, C418: 0.1u; C_0603_1608Metric; MPN C0603C104K4PACTU
C406: 10u; C_0805_2012Metric; MPN C0805C106K3PACTU
J401: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical; MPN 77313-118-12LF
R401: 100R; R_0603_1608Metric; MPN CR0603-JW-101ELF
R402, R403, R405, R407, R412, R415: 10k; R_0603_1608Metric; MPN CR0603-JW-103ELF
R404, R406, R413, R416: 49R9; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-49R9ELF
R408, R411, R414, R418: 150R; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-1500ELF
R409, R417: 140R; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-1400ELF
R410: 100k; R_0603_1608Metric; MPN CR0603-FX-1003ELF
U401: ICE40LP1K-CM49; UCBGA-49_3x3mm_Layout7x7_P0.4mm; MPN ICE40LP1K-CM49
X401: 25 MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ECS-3225MV-250-BN-TR

Connections:
/AUX0_RX_N: C417.1; also elsewhere on the board
/AUX0_RX_P: C413.1; also elsewhere on the board
/AUX0_TX_N: C418.2; also elsewhere on the board
/AUX0_TX_P: C416.2; also elsewhere on the board
/AUX1_RX_N: C411.1; also elsewhere on the board
/AUX1_RX_P: C408.1; also elsewhere on the board
/AUX1_TX_N: C414.2; also elsewhere on the board
/AUX1_TX_P: C412.2; also elsewhere on the board
/AUX_CMD0: U401.A2; also elsewhere on the board
/AUX_CMD1: U401.B3; also elsewhere on the board
/AUX_CMD2: U401.A3; also elsewhere on the board
/AUX_CMD3: U401.B4; also elsewhere on the board
/AUX_CMD4: U401.A4; also elsewhere on the board
/AUX_CMD5: U401.A5; also elsewhere on the board
/AUX_CMD6: U401.A6; also elsewhere on the board
/AUX_CMD7: U401.A7; also elsewhere on the board
/AUX_SPI_CIPO: U401.F3; also elsewhere on the board
/AUX_SPI_COPI: U401.D4; also elsewhere on the board
/AUX_SPI_SCK: U401.G4; also elsewhere on the board
/AUX_STATUS0: U401.C7; also elsewhere on the board
/AUX_STATUS1: U401.D7; also elsewhere on the board
/AUX_STATUS2: U401.E7; also elsewhere on the board
/AUX_STATUS3: U401.F7; also elsewhere on the board
/AUX_STATUS4: U401.C4; also elsewhere on the board
/AUX_STATUS5: U401.C5; also elsewhere on the board
/AUX_STATUS6: U401.C6; also elsewhere on the board
/AUX_STATUS7: U401.D6; also elsewhere on the board
/aux_controller/AUX0_RX_FPGA_N: C417.2, R416.2, U401.F2
/aux_controller/AUX0_RX_FPGA_P: C413.2, R413.1, U401.E2
/aux_controller/AUX0_TX_FPGA_N: R418.2, U401.C1
/aux_controller/AUX0_TX_FPGA_P: R414.2, U401.D1
/aux_controller/AUX1_RX_FPGA_N: C411.2, R406.2, U401.B2
/aux_controller/AUX1_RX_FPGA_P: C408.2, R404.1, U401.C2
/aux_controller/AUX1_TX_FPGA_N: R411.2, U401.B1
/aux_controller/AUX1_TX_FPGA_P: R408.2, U401.A1
/aux_controller/AUX_REFCLK: U401.G3, X401.3
/aux_controller/CDONE: J401.5, U401.D5
/aux_controller/GNDPLL: C406.2, C407.2, U401.G1
/aux_controller/SCK: J401.10, U401.F6
/aux_controller/SDI: J401.8, U401.G6
/aux_controller/SDO: J401.7, U401.F5
/aux_controller/SS: J401.2, R402.2, U401.E6
/aux_controller/VCCPLL: C406.1, C407.1, R401.2, U401.F1
/aux_controller/~CRESET: J401.3, R407.2, U401.G5
/~AUX_SPI_CS: U401.F4; also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C409.2, C410.2, C415.2, J401.4, R405.2, R415.2, U401.E3, U401.E4, U401.E5, X401.2; also elsewhere on the board
unnamed: C410.1, R403.2, R404.2, R405.1, R406.1
unnamed: C412.1, R408.1, R409.1
unnamed: C414.1, R409.2, R411.1
unnamed: C415.1, R412.2, R413.2, R415.1, R416.1
unnamed: C416.1, R414.1, R417.1
unnamed: C418.1, R417.2, R418.1
unnamed: R410.2, X401.1

Notes on the sheet:
Ref. TN-02052 Ver. 1.2 Sec. 5.2
Ref. UG-02042 Ver. 26.4

Schematic: dual_sgmii_phy.sch, Gimlet Management Network Bringup

Parts:
C501: 1u; C_0603_1608Metric; MPN C0603C105K4PACTU
C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C535, C536, C537, C538, C539, C540, C541, C542, C543, C544, C545, C546, C547, C548, C549, C550, C551, C552, C553, C554: 0.1u; C_0603_1608Metric; MPN C0603C104K4PACTU
C512: 0.15u; C_0603_1608Metric; MPN C0603C154K4RACTU
C533, C534, C555, C556: 22u; C_0805_2012Metric; MPN C0805C226K9PACTU
D501, D502: 1N4148WS-G RVG; D_SOD-323; MPN 1N4148WS-G RVG
D503, D504, D505, D506, D507, D508, D509, D510: LED; LED_0603_1608Metric; MPN 150060AS75000
R501, R505, R506, R507, R508, R509, R512, R513, R514, R515, R519, R523, R532, R533: 10k; R_0603_1608Metric; MPN CR0603-JW-103ELF
R502: 220R; R_0603_1608Metric; MPN CR0603-JW-221ELF
R503: 910R; R_0603_1608Metric; MPN CR0603-JW-911ELF
R504, R511, R534, R535: 0R; R_0603_1608Metric; MPN CR0603-J/-000ELF
R510, R516, R520, R522, R524, R525, R526, R527, R528, R529, R530, R531: 49R9; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-49R9ELF
R517: 2k; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-2001ELF
R518: 100k; R_0603_1608Metric; MPN CR0603-FX-1003ELF
R521: 620R; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-6200ELF
U501: VSC8552XKS-02; BGA-256_17.0x17.0mm_Layout16x16_P1.0mm_Ball0.5mm_Pad0.4mm_N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; MPN VSC8552XKS-02
X501: 25 MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ECS-3225MV-250-BN-TR

Connections:
/BaseFX_Termination/PORT0_PHY_RX_N: U501.T15; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_RX_P: U501.R15; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_TX_N: U501.T14; also elsewhere on the board
/BaseFX_Termination/PORT0_PHY_TX_P: U501.R14; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_RX_N: U501.T11; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_RX_P: U501.R11; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_TX_N: U501.T10; also elsewhere on the board
/BaseFX_Termination/PORT1_PHY_TX_P: U501.R10; also elsewhere on the board
/SGMII0_RX_N: C506.1; also elsewhere on the board
/SGMII0_RX_P: C503.1; also elsewhere on the board
/SGMII0_TX_N: C505.1; also elsewhere on the board
/SGMII0_TX_P: C504.1; also elsewhere on the board
/SGMII1_RX_N: C510.1; also elsewhere on the board
/SGMII1_RX_P: C508.1; also elsewhere on the board
/SGMII1_TX_N: C509.1; also elsewhere on the board
/SGMII1_TX_P: C507.1; also elsewhere on the board
/SMI_MDC: U501.P2; also elsewhere on the board
/SMI_MDIO: U501.N2; also elsewhere on the board
/dual_sgmii_phy/CLK_SQUELCH: R518.2, U501.E15
/dual_sgmii_phy/COMA_MODE: R519.1, U501.L3; also elsewhere on the board
/dual_sgmii_phy/LED0_0: D503.1 (K), U501.G1
/dual_sgmii_phy/LED0_1: D504.1 (K), U501.H1
/dual_sgmii_phy/LED1_0: D505.1 (K), U501.G2
/dual_sgmii_phy/LED1_1: D506.1 (K), U501.H2
/dual_sgmii_phy/LED2_0: D507.1 (K), U501.G3
/dual_sgmii_phy/LED2_1: D508.1 (K), U501.H3
/dual_sgmii_phy/LED3_0: D509.1 (K), U501.G4
/dual_sgmii_phy/LED3_1: D510.1 (K), U501.H4
/dual_sgmii_phy/PHYADD2: R506.2, R513.2, U501.G13
/dual_sgmii_phy/PHYADD3: R507.2, R514.2, U501.G14
/dual_sgmii_phy/PHYADD4: R508.2, R515.2, U501.F14
/dual_sgmii_phy/PHY_GPIO0: R533.2, U501.N14; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO1: R532.2, U501.M14; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO4: U501.L13; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO5: U501.L14; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO8: U501.K13; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO9: U501.K14; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO10: U501.K15; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO11: U501.K16; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO12: U501.J14; also elsewhere on the board
/dual_sgmii_phy/PHY_GPIO13: U501.H14; also elsewhere on the board
/dual_sgmii_phy/PHY_REFCLK: R502.1, X501.3
/dual_sgmii_phy/PHY_REFCLK_EN: R501.2, X501.1
/dual_sgmii_phy/RCVRDCLK1: U501.F16; also elsewhere on the board
/dual_sgmii_phy/RCVRDCLK2: U501.G16; also elsewhere on the board
/dual_sgmii_phy/REFCLK_P: R502.2, R503.2, U501.D1
/dual_sgmii_phy/REFCLK_SEL2: R509.2, R512.2, U501.E1
/dual_sgmii_phy/REF_FILT_A: C501.1, U501.D3
/dual_sgmii_phy/REF_REXT_A: R517.1, U501.D4
/dual_sgmii_phy/REXT0: R521.1, U501.P14
/dual_sgmii_phy/REXT1: R521.2, U501.N13
/dual_sgmii_phy/RGMII0_TXCLK: R504.1, U501.G15
/dual_sgmii_phy/RGMII1_TXCLK: R511.1, U501.K1
/dual_sgmii_phy/SGMII0_RX_PHY_N: C506.2, R516.2, U501.P16
/dual_sgmii_phy/SGMII0_RX_PHY_P: C503.2, R510.1, U501.P15
/dual_sgmii_phy/SGMII0_TX_PHY_N: C505.2, U501.N16
/dual_sgmii_phy/SGMII0_TX_PHY_P: C504.2, U501.N15
/dual_sgmii_phy/SGMII1_RX_PHY_N: C510.2, R522.2, U501.T12
/dual_sgmii_phy/SGMII1_RX_PHY_P: C508.2, R520.1, U501.R12
/dual_sgmii_phy/SGMII1_TX_PHY_N: C509.2, U501.T13
/dual_sgmii_phy/SGMII1_TX_PHY_P: C507.2, U501.R13
/dual_sgmii_phy/TCK: U501.F3; also elsewhere on the board
/dual_sgmii_phy/TDI: U501.F2; also elsewhere on the board
/dual_sgmii_phy/TDO: U501.F1; also elsewhere on the board
/dual_sgmii_phy/TMS: U501.E2; also elsewhere on the board
/dual_sgmii_phy/TRST: R505.1, U501.E3; also elsewhere on the board
/dual_sgmii_phy/VDD1A: C533.1, C545.1, C546.1, C547.1, C548.1, C549.1, C550.1, C551.1, C552.1, C553.1, C554.1, R534.1, U501.C7, U501.C8, U501.C9, U501.C13, U501.P6, U501.P7, U501.P8, U501.P9, U501.P10, U501.P11
/dual_sgmii_phy/VDD25A: C535.1, C536.1, C537.1, C538.1, C539.1, C540.1, C541.1, C542.1, C543.1, C544.1, C556.1, R535.1, U501.C2, U501.C4, U501.C6, U501.C11, U501.C14, U501.E4, U501.E13, U501.P5, U501.P12, U501.P13
/dual_sgmii_phy/~PHY_RST: D502.1; also elsewhere on the board
/dual_sgmii_phy/~RST: C512.1, D501.2, D502.2, R523.2, U501.M3
/~SMI_INTR: U501.M2; also elsewhere on the board
GND: C501.2, C502.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.2, C532.2, C533.2, C534.2, C535.2, C536.2, C537.2, C538.2, C539.2, C540.2, C541.2, C542.2, C543.2, C544.2, C545.2, C546.2, C547.2, C548.2, C549.2, C550.2, C551.2, C552.2, C553.2, C554.2, C555.2, C556.2, R503.1, R504.2, R505.2, R511.2, R512.1, R513.1, R514.1, R515.1, R517.2, R519.2, U501.B1, U501.B16, U501.C5, U501.C12, U501.D5, U501.D6, U501.D7, U501.D8, U501.D9, U501.D10, U501.D11, U501.D12, U501.E6, U501.E7, U501.E8, U501.E9, U501.E10, U501.E11, U501.F4, U501.F6, U501.F7, U501.F8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; also elsewhere on the board
unnamed: C502.1, R510.2, R516.1
unnamed: C511.1, R520.2, R522.1
unnamed: D503.2 (A), R524.2
unnamed: D504.2 (A), R525.2
unnamed: D505.2 (A), R526.2
unnamed: D506.2 (A), R527.2
unnamed: D507.2 (A), R528.2
unnamed: D508.2 (A), R529.2
unnamed: D509.2 (A), R530.2
unnamed: D510.2 (A), R531.2

Notes on the sheet:
Reset must be asserted for 2 ms after power+clock
18x VDD1 10x VDD1A 4x VDD25 10x VDD25A 69x VSS
Charges to VIH(min)=1.85V in >2 ms
1V+2.5V must be stable before VSC RESET is released
Vf = 2V, 49.9 Ohm = 10 mA 10 mA forward current = approx. 75 mcd
Review RST rise time requirements - done (it's not specified) Add supervisor

Schematic: ethernet_switch.sch, Gimlet Management Network Bringup

Parts:
C601, C602, C603, C604, C605, C606, C607, C608, C609, C610: 0.1u; C_0603_1608Metric; MPN C0603C104K4PACTU
C611: 10u; C_0805_2012Metric; MPN C0805C106K3PACTU
D601, D602, D603, D604: LED; LED_0603_1608Metric; MPN 150060AS75000
D605, D606: 1N4148WS-G RVG; D_SOD-323; MPN 1N4148WS-G RVG
FB601: \\; R_0603_1608Metric; MPN CR0603-J/-000ELF
R601, R602, R603: 0R; R_0603_1608Metric; MPN CR0603-J/-000ELF
R604, R608, R613, R614, R615, R617: 10k; R_0603_1608Metric; MPN CR0603-JW-103ELF
R605, R606, R607: 4k7; R_0603_1608Metric; MPN CR0603-JW-472ELF
R609, R610, R611, R612: 130R; R_0603_1608Metric; MPN CR0603-JW-131ELF
R616: 6k49; R_0603_1608Metric; Tolerance 1%; MPN CR0603-FX-6491ELF
U601: KSZ8463FRL; LQFP-64_10x10mm_P0.5mm; MPN KSZ8463FRLI
X601: 25 MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ECS-3225MV-250-BN-TR

Connections:
+3V3: C605.1, C608.1, C609.1, C610.1, D605.1, R602.1, R604.1, R605.1, R606.1, R607.1, R609.1, R610.1, R611.1, R612.1, R613.1, R614.1, R615.1, R617.1, U601.21, U601.30, U601.56; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_RX_N: U601.1; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_RX_P: U601.2; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_TX_N: U601.4; also elsewhere on the board
/BaseFX_Termination/PORT0_SW_TX_P: U601.5; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_RX_N: U601.10; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_RX_P: U601.11; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_TX_N: U601.13; also elsewhere on the board
/BaseFX_Termination/PORT1_SW_TX_P: U601.14; also elsewhere on the board
/RMII_CRS_DV: U601.31; also elsewhere on the board
/RMII_REF_CLK: R603.2; also elsewhere on the board
/RMII_RXD0: R604.2, U601.35; also elsewhere on the board
/RMII_RXD1: U601.34; also elsewhere on the board
/RMII_TXD0: U601.26; also elsewhere on the board
/RMII_TXD1: U601.25; also elsewhere on the board
/RMII_TX_EN: U601.22; also elsewhere on the board
/SPI_DI: R606.2, U601.45; also elsewhere on the board
/SPI_DO: R608.1, U601.41; also elsewhere on the board
/SPI_SCLK: U601.44; also elsewhere on the board
/ethernet_switch/3V3A: C606.1, C607.1, R602.2, U601.9
/ethernet_switch/EN_REFCLKO: R615.2, U601.23, X601.1
/ethernet_switch/FXSD1: R614.2, U601.64
/ethernet_switch/FXSD2: R613.2, U601.15
/ethernet_switch/ISET: R616.1, U601.7
/ethernet_switch/P1LED0: D601.1 (K), U601.60
/ethernet_switch/P1LED1: D602.1 (K), U601.59
/ethernet_switch/P2LED0: D603.1 (K), U601.62
/ethernet_switch/P2LED1: D604.1 (K), U601.61
/ethernet_switch/REFCLK_I: R601.2, R603.1, U601.27
/ethernet_switch/REFCLK_O: R601.1, U601.32
/ethernet_switch/SW_GPIO0: U601.48; also elsewhere on the board
/ethernet_switch/SW_GPIO1: U601.49; also elsewhere on the board
/ethernet_switch/SW_GPIO2: U601.52; also elsewhere on the board
/ethernet_switch/SW_GPIO3: U601.53; also elsewhere on the board
/ethernet_switch/SW_GPIO4: U601.54; also elsewhere on the board
/ethernet_switch/SW_GPIO5: U601.55; also elsewhere on the board
/ethernet_switch/SW_GPIO6: U601.58; also elsewhere on the board
/ethernet_switch/SW_GPIO7: U601.38; also elsewhere on the board
/ethernet_switch/SW_GPIO8: U601.46; also elsewhere on the board
/ethernet_switch/SW_GPIO9: U601.36; also elsewhere on the board
/ethernet_switch/SW_GPIO10: U601.37; also elsewhere on the board
/ethernet_switch/SW_GPIO11: U601.47; also elsewhere on the board
/ethernet_switch/VDD_AL: C601.1, C602.1, FB601.2, U601.6, U601.16
/ethernet_switch/VDD_L: C603.1, C604.1, FB601.1, U601.40, U601.51
/ethernet_switch/X1: U601.18, X601.3
/ethernet_switch/~RST: C611.1, D605.2, D606.2, R617.2, U601.63
/ethernet_switch/~SW_RST: D606.1; also elsewhere on the board
/~SPI_CS: R605.2, U601.42; also elsewhere on the board
/~SW_INTR: R607.2, U601.43; also elsewhere on the board
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, R608.2, R616.2, U601.3, U601.8, U601.12, U601.20, U601.29, U601.39, U601.50, U601.57, X601.2; also elsewhere on the board
unnamed: D601.2 (A), R609.2
unnamed: D602.2 (A), R610.2
unnamed: D603.2 (A), R611.2
unnamed: D604.2 (A), R612.2

Notes on the sheet:
3x VDD_IO, 2x VDD_L
MIIM-Mode Strap
Clock Mode Strap (CMS1)
Clock Mode Strap (CMS2)
Clock Mode Strap (CMS3)
Clock Mode Strap (CMS4)
Datasheet Figure 7-14
Config 3 (Internal + Off-Board) is specified in BOM
Review RST rise time requirements - done (it's OK)
Input from Arjen on SMI/SPI - need to route SPI
3V3 to connect to STM32? done - see notes
VIH = 2.1V Internal R = 27 kOhm min. Pull Resistance <= 15 kOhm
VIL = 0.9V Internal R = 27 kOhm min. Pull Resistance <= 10 kOhm
RST must stay low for 10ms after supplies stable
Vf = 2V, 130 Ohm = 10 mA 10 mA forward current = approx. 75 mcd
Clock Mode Strap Settings: CMS1 CMS2 CMS3 CMS4 Y N N Y - External RMII_REF_CLK N Y Y N - Internal REFCLK_O not provided off-board N Y Y Y - Internal REFCLK_O provided off-board

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
Board: 6 copper layers, 150.0 x 105.0 mm, 322 parts (0 on the bottom side), 236 nets.
