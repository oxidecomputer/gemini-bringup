# Repository oxidecomputer/gemini-bringup (continued)

## KiCad design nic2/nic2.kicad_pcb

File nic2/README.md:

# Gimletlet NIC2
This board plugs into the Gimletlet expansion port and uses the KSZ8463FRLI
to convert RMII to two RJ45 ethernet jacks.

- [Changelog and review doc](https://docs.google.com/document/d/1XRyrzR-EBEqLgqTISPo68WqQa26gW9Hyr770QtQbXls/edit#heading=h.k6cnm5wj7rqd)
- [Inventory Spreadsheet](https://docs.google.com/spreadsheets/d/1lzRwmGw_XATJ5_8DHBT_nESm4jvBn5tmuN_NV4cPHXA/edit?usp=sharing)

## Bringup guide
- Connect the NIC to a Gimletlet
- Connect 12V power and SWD as usual
- Connect ethernet to the upper jack (J2)
- Flash the Gimletlet with a recent [Hubris](https://github.com/oxidecomputer/hubris) image:
```console
$ cargo xtask flash app/gimletlet/app.toml
```
- With the image running, lights should appear on the ethernet jack
- Read back the MAC address (which is randomly assigned):
```console
$ cargo xtask humility app/gimletlet/app.toml -- readvar MAC_ADDRESS
humility: attached via ST-Link V3
MAC_ADDRESS (0x20013640) =  {
    value: [
        0xe,
        0x1d,
        0xdd,
        0xf8,
        0xfb,
        0x69
    ]
}
```
- Convert that MAC address to an IPv6 link-local address, e.g. using [this tool](https://ben.akrin.com/mac-address-to-ipv6-link-local-address-online-converter/)
- Ping the device using `ping6` (using your MAC address and replacing `en0`
  with your network interface name)
```console
$ ping6 fe80::c1d:ddff:fef8:fb69%en0
PING6(56=40+8+8 bytes) fe80::18b6:dfe2:7a83:824f%en0 --> fe80::c1d:ddff:fef8:fb69%en0
16 bytes from fe80::c1d:ddff:fef8:fb69%en0, icmp_seq=0 hlim=64 time=3.228 ms
16 bytes from fe80::c1d:ddff:fef8:fb69%en0, icmp_seq=1 hlim=64 time=3.680 ms
16 bytes from fe80::c1d:ddff:fef8:fb69%en0, icmp_seq=2 hlim=64 time=2.010 ms
16 bytes from fe80::c1d:ddff:fef8:fb69%en0, icmp_seq=3 hlim=64 time=2.851 ms
^C
--- fe80::c1d:ddff:fef8:fb69%en0 ping6 statistics ---
4 packets transmitted, 4 packets received, 0.0% packet loss
round-trip min/avg/max/std-dev = 2.010/2.942/3.680/0.613 ms
```

Congratulations! You have a working Gimletlet + NIC.

### Testing note
When testing multiple NICs, the Gimletlet does not need to be reflashed,
and the MAC / IPv6 address will not change, so you can detach the debugger.

**Always remove 12V power from the Gimletlet before swapping the NIC.**

Parts:
C1, C3, C4, C5, C6, C7, C8: 1 µF; C_0402_1005Metric; MPN C0402C105K9PAC7800
C9, C10, C11, C12: 0.1 µF; C_0402_1005Metric; MPN C0402C104K9RAC7867
C13: 4700 pF; C_0402_1005Metric; MPN C0402C472K3RAC7867
C14: 10 µF; C_0805_2012Metric; MPN C0805C106K9RAC7800
D1: LED; LED_0402_1005Metric; MPN XZMDK68W-2
D2: LED; LED_0402_1005Metric; MPN XZMOK68W-2
D3, D6: LED; LED_0402_1005Metric; MPN XZVGR68W-3
D4: MPN VLMB1500-GS08
D5: LED; LED_0402_1005Metric; MPN XZVG68W-2
FB1: FerriteBead; R_0402_1005Metric; MPN BLM15AX601SN1D
FID1, FID2, FID3: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2: MountingHole; MountingHole_3.2mm_M3
H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_2Rows-41Pins; DF9-41P-1V; MPN DF9-41P-1V(69)
J2, J3: Wuerth_74980111211; RJ45_Wuerth_74980111211_Horizontal; MPN 74980111211
J4: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
LOGO1: LOGO; OXIDE_Wordmark
R1, R2, R5: 10KΩ; R_0402_1005Metric; MPN CRG0402F10K
R3, R6: 4.7 KΩ; R_0402_1005Metric; MPN CRG0402F4K7
R4: 6.49 KΩ; R_0402_1005Metric; MPN RC0402FR-076K49L
R7, R8, R9, R10, R12, R13, R14, R15, R16, R17: 143Ω; R_0402_1005Metric; MPN RC0402FR-07143RL
R11: 1 MΩ; R_0402_1005Metric; MPN CRG0402F1M0
U1: KSZ8463FRLI; LQFP-64_10x10mm_P0.5mm; MPN KSZ8463FRLI
U2, U3: TPD4S010DQAR; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4S010DQAR
X1: ASE-25.000MHZ-LC; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN ASE-25.000MHZ-LC-T

Connections:
+3V3: C1.2, C3.2, C4.2, C5.2, C14.2, D5.2 (A), J1.19, J1.21, J1.23, J1.33, J1.35, J1.37, J4.7, R1.1, R3.1, R5.1, R6.2, R7.2, R8.2, R9.2, R10.2, U1.9 (VDDA_3V3), U1.21 (VDD_IO), U1.30 (VDD_IO), U1.56 (VDD_IO), X1.4 (Vdd)
/I2C4_SCL: J1.22
/I2C4_SDA: J1.24
/P1LED0: J2.11, U1.60 (P1LED0)
/P1LED1: J2.2, U1.59 (P1LED1)
/P1V3: C6.2, FB1.1, U1.40 (VDD_L), U1.51 (VDD_L)
/P1V3_FILT: C7.2, C8.2, FB1.2, U1.6 (VDD_AL), U1.16 (VDD_COL)
/P2LED0: J3.11, U1.62 (P2LED0)
/P2LED1: J3.2, U1.61 (P2LED1)
/RMII_CRS_DV: J1.6, U1.31 (RX_DV)
/RMII_REF_CLK: J1.2, U1.27 (REFCLK_I), U1.32 (REFCLK_O)
/RMII_RXD0: J1.8, U1.35 (RXD0)
/RMII_RXD1: J1.10, U1.34 (RXD1)
/RMII_TXD0: J1.38, U1.26 (TXD0)
/RMII_TXD1: J1.40, U1.25 (TXD1)
/RMII_TXEN: J1.36, U1.22 (TX_EN)
/RX1_N: J2.8 (RD-), U1.1 (RXM1), U2.5 (D2-), U2.6 (NC)
/RX1_P: J2.6 (RD+), U1.2 (RXP1), U2.4 (D2+), U2.7 (NC)
/RX2_N: J3.8 (RD-), U1.10 (RXM2), U3.5 (D2-), U3.6 (NC)
/RX2_P: J3.6 (RD+), U1.11 (RXP2), U3.4 (D2+), U3.7 (NC)
/SPI4_MISO: J1.30, J4.5, U1.41 (SPI_DO)
/SPI4_MOSI: J1.32, J4.4, R3.2, U1.45 (SPI_DI/MDIO)
/SPI4_SCK: J1.28, J4.6, U1.44 (SPI_SCLK/MDC)
/SP_MDC: J1.3
/SP_MDIO: J1.5
/SP_PB0: J1.13
/SP_PB1: J1.14
/SP_PB2: J1.15
/SP_PF11: J1.16
/SP_PF12: J1.17
/TX1_N: J2.5 (TD-), U1.4 (TXM1), U2.2 (D1-), U2.9 (NC)
/TX1_P: J2.3 (TD+), U1.5 (TXP1), U2.1 (D1+), U2.10 (NC)
/TX2_N: J3.5 (TD-), U1.13 (TXM2), U3.2 (D1-), U3.9 (NC)
/TX2_P: J3.3 (TD+), U1.14 (TXP2), U3.1 (D1+), U3.10 (NC)
/~I2C4_SMBA: J1.20
/~INTR: R6.1, U1.43 (~INTR)
/~SMI_IRQ: J1.7
/~SMI_RESET: J1.9
/~SPI4_CS: J1.27, J4.3, U1.42 (SPI_CSN)
/~SPI4_INT: J1.29
/~SPI4_RESET: D6.2 (A), J1.31, J4.2, R2.2, U1.63 (~RST)
Earth: C13.2, H3.1, H4.1, J2.10, J2.SH, J3.10, J3.SH, R11.2
GND: C1.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, J1.1, J1.4, J1.11, J1.12, J1.18, J1.25, J1.26, J1.34, J1.39, J1.41, J4.1, R2.1, R4.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, U1.3 (AGND), U1.8 (AGND), U1.12 (AGND), U1.15 (FXSD2), U1.20 (DGND), U1.29 (DGND), U1.39 (DGND), U1.50 (DGND), U1.57 (DGND), U1.64 (FXSD1), U2.3 (GND), U2.8 (GND), U3.3 (GND), U3.8 (GND), X1.2 (GND)
unnamed: C9.1, J2.4 (TCT)
unnamed: C10.1, J2.7 (RCT)
unnamed: C11.1, J3.4 (TCT)
unnamed: C12.1, J3.7 (RCT)
unnamed: D1.1 (K), R13.2
unnamed: D1.2 (A), U1.55 (GPIO5)
unnamed: D2.1 (K), R14.2
unnamed: D2.2 (A), U1.54 (GPIO4)
unnamed: D3.1 (K), R15.2
unnamed: D3.2 (A), U1.53 (GPIO3)
unnamed: D4.1 (K), R16.2
unnamed: D4.2 (A), U1.52 (GPIO2)
unnamed: D5.1 (K), R12.2
unnamed: D6.1 (K), R17.2
unnamed: J2.1, R8.1
unnamed: J2.12, R7.1
unnamed: J3.1, R10.1
unnamed: J3.12, R9.1
unnamed: R1.2, X1.1 (EN)
unnamed: R4.2, U1.7 (ISET)
unnamed: R5.2, U1.23 (EN_REFCLK_O)
unnamed: U1.18 (X1), X1.3 (OUT)

Notes on the sheet:
Note that CHASSIS / SHIELD is separate from GND and connected through this RC network; this is based on TI's design guide. ("Ethernet: How to design 100BASE-TX Ethernet schematics")
Enable REFCLK_O output
The datasheet has a more complicated reset circuit (to do a delayed reset at power on), but we can handle that sequencing from the SP.
Not sure why this needs a pull-up, but the datasheet claims it does.
Debug header
Copper mode, so pull Fiber Signal Detect inputs to GND.
Max DCR = 340 mΩ Max current = 84 mA Worst-case voltage drop = 28 mV Worst-case P1V3_FILT = 1.27V (ish) Min input spec = 1.25V
This is left floating, which configures the chip to expect a 25 MHz clock on X1/X2
NIC connector from Gimletlet
Power LED and bulk capacitance

Board: 4 copper layers, 70.8 x 66.5 mm, 53 parts (11 on the bottom side), 52 nets.

## KiCad design samtec_dbg/samtec_dbg/samtec_dbg.kicad_pcb

Parts:
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical_SMD
J2: SFM-105-02-X-DH-XX; SAMTEC_SFM-105-02-X-DH-XX; PARTREV D
J3: TFC-105-02-F-D-A-K; SAMTEC_TFC-105-02-F-D-A-K; PARTREV R

Connections:
GND: J1.5, J2.05, J3.05
unnamed: J1.1, J2.01, J3.01
unnamed: J1.2, J2.02, J3.02
unnamed: J1.3, J2.03, J3.03
unnamed: J1.4, J2.04, J3.04
unnamed: J1.6, J2.06, J3.06
unnamed: J1.7, J2.07, J3.07
unnamed: J1.8, J2.08, J3.08
unnamed: J1.9, J2.09, J3.09
unnamed: J1.10, J2.10, J3.10

Notes on the sheet:
Bottom-side connector for connecting to Oxide board
Top-side connector for connecting debug cables

Board: 4 copper layers, 14.0 x 40.0 mm, 4 parts (1 on the bottom side), 10 nets.

Other parts of the board:
Ref**: Val**; OXIDE_Wordmark

## Commit log (part)

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2020-08-12 SMD resistor packs @ fan controller, i2c mux
2020-08-12 Initialize PCB with 4-layer stackup
2020-08-12 Initial import to PCB.
2020-08-14 doc: mechanical drawings for STM32H7 socket
2020-08-14 Loosen STM32H7 socket courtyard
2020-08-14 SP Eth: space wires more to avoid accidental shorts
    (like the one Arjen spotted)
2020-08-14 SP: switch host UART to RS232 levels
    fixes #1
2020-08-15 RoT: Move support circuitry to LPC55 carrier board
    Reduces trace lengths between LPC55 and bypass caps, DCDC inductor, and
    crystals. Instead of duplicating a bunch of these components on Gemini
    Bringup, plan to always use a carrier with Gemini Bringup.
    Reduced qty of signals on carrier connector to allow for additional
    ground returns while keeping to a low-ish pin count (50 circuits).
2020-08-17 Resolve merge conflict from 2020a2de7
    2020a2de7 reverted the two previous commits to the SP schematic page. I have taken
    a shot at reconstructing it.
2020-08-17 Shrink expansion connector pitch, update PCB
2020-08-18 Series resistors on high-speed signals.
    fixes #7
2020-08-18 SP: diode to drain reset cap at powerdown
    fixes #11
2020-08-24 SP: GPIO control of Eth Switch reset
    fixes #22
2020-08-24 Eth Switch: remove REFCLKO pullup
    fixes #24
2020-08-24 Adjust all crystal load capacitances.
    fixes #8
2020-08-25 PCB: route fan controller area
2020-08-25 PCB: route power area
2020-08-26 Crystal tweaks.
    - Switch crystals to smaller footprints
    - Switch SP to use 8MHz crystal for reduced power/EMI
    - Adjust caps to match named part numbers
2020-08-26 PCB: QSPI routing and skew control
2020-08-26 Eth: fix mistakes, route switch layout
    I've switched the Magjacks from an Amphenol through-hole part with an
    awful pin order, to a Wuerth surface-mount part with a much more
    reasonable pinout.
    I found a few mistakes in the schematic.
    - LED anodes were tied to transistor center taps; moved to 3v3.
    - Reset line was doubly pulled up; removed one of two pullups.
2020-08-27 Import KiCad 5.1.6 libraries as submodules
2020-08-27 Update GitHub workflow to fetch submodules
2020-08-27 lib: add SMD IDC connectors that KiCad lacks for some reason
2020-08-27 Alter lib tables to point at submodules
2020-08-27 Swap more connectors to SMT, route UART and SPI
2020-08-28 Molex SL SMT footprint library
2020-08-28 Change baseboard/carrier connector footprint with Hirose DF9-51x-1V
2020-08-28 Change fan connectors to Dell-style SMD, densify
2020-08-28 Route SMBus mux, shrink board
2020-08-28 Route remaining I2C buses - all SP exit routing complete
2020-08-28 LPC55 carrier outline on main board
2020-08-29 MB: all SP signals routed, removed excess caps
2020-08-31 Provide submodule instructions in README
2020-08-31 lpc55_carrier: current limiting resistors between connector/pullups rather than pullups/lpc55
2020-09-01 lpc55_carrier: pull up signals to VDD instead of 3V3
2020-09-01 MB: swap remaining through-hole headers for SMD
2020-09-01 lpc55_carrier: add 4.7uF bulk cap to VDDA
2020-09-01 MB: annotate everything with mfg/MPN
2020-09-02 oxide logo
2020-09-03 MB: diode selection
    Switched 0603 diodes to SOD-323 due to availability
    Adjusted H7 debug LED current limit resistors for Vf
2020-09-03 MB: assign resistor networks
    ...and replace the x5 networks with discretes because they don't exist.
2020-09-03 lpc55_carrier: rearrange pins on carrier to board connector to ease routing
2020-09-03 lpc55_carrier: remove LEDs as they will not be visible when carrier is mounted on baseboard
2020-09-04 MB: shorten QSPI_CLK to improve clk-to-out timing
    Per review comment from Mark. Stubs on high-speed lines not fixed in this commit.
2020-09-04 MB: increase isolation of FPGA SPI SCK
    Per review comments from Mark.
2020-09-10 lpc55_carrier: move to 4-layer with 2 inner ground planes
    Reduces potential problems where signals passed over reference plane
    voids or crossed between reference planes.
2020-09-14 lpc55_carrier: layout feedback, no really
2020-09-14 lpc55_carrier: add MPN for LPC55
2020-09-15 MB: update RoT carrier pinout
2020-09-17 MB: finish routing
    This finalizes layout and routing around the RoT carrier connector. I
    have managed to avoid the layout gaffes that Mark pointed out in his
    review -- clocks don't change layer, and when signals must change layer,
    I put vias in the slower speed signals first.
2020-09-25 lpc55_carrier: update connector footprint to DF9-51S
2020-09-26 fans: expand PCA9306DP to full, orderable MPN
2020-09-26 sp: expand MAX13235EET to full, orderable part number
2020-09-30 MB: re-lay-out RoT for revised connector and mechanicals
2020-10-01 MB: labeling
2020-10-01 MB: logos etc
2020-10-02 MB: address feedback from board mtg
2020-10-12 gemini-bringup: Add CPNs for all components
2020-10-19 lpc55_carrier: Add CPNs for all components
2020-10-19 lpc55_carrier: add mounting holes to schematic
2020-10-19 lpc55_carrier: layout update for D103 footprint and mounting holes
2020-10-19 lpc55_carrier: enabled back component layers
    No components will be placed on the back but since the back will be
    facing up when the carrier is installed, it would be a shame to not have
    _some_ artwork.
2020-11-03 Schematic and PCB checklists
    Adopted from https://github.com/azonenberg/pcb-checklist
2020-11-03 lpc55_carrier: fix name names on LPC55 xtal pins
2020-11-03 lpc55_carrier: fix box around bypass caps
2020-11-04 lpc55_carrier: Power/voltage/tolerance/etc ratings for passives
    Update footprints accordingly.
2020-11-04 lpc55_carrier: document POR pin modes
2020-11-04 lpc55_carrier: remove external pullups on SWD as internal pull-up/down are enabled at POR
2020-11-04 lpc55_carrier: series terminate SP->RoT SPI drivers (MISO)
2020-11-04 lpc55_carrier: change SWD current limit resistors to 22R
    This is sole use of 100R while 22R is used for series termination in
    many places.
    3.3V / 22R = 0.150A
2020-11-04 lpc55_carrier: calculate and document xtal load caps
2020-11-04 lpc55_carrier: schematic checklist complete
2020-11-04 lpc55_carrier: assign footprints for test points
2020-11-09 lib: even smaller board identifier that drops the logo
2020-11-09 lib: HTQFP-64: divide exposed pad paste into quadrants
2020-11-09 lpc55_carrier: layout ready for CAM
2020-11-10 rot: remove unnecessary series termination on HS_SPI_MISO
    Termination is handled on lpc55_carrier. No need to terminate in the
    middle of the trace.
2020-11-10 fans: always deassert fan controller's external full speed request
    Datasheet doesn't clearly indicate FULL_SPEED# has an internal pull up
    so tie to +5V to have defined state.
2020-11-13 fans: specify rating constraints on passives
2020-11-13 i2c-gpio: specify rating constraints on passives
2020-11-13 qpsi: specify rating constraints on passives
2020-11-13 i2c-ext: specify rating constraints on passives
2020-11-18 sp: recalculate and document crystal load capacitor constraints
2020-11-18 sp: specify footprint for R339
2020-11-18 gemini-bringup: resistor power rating constraints
2020-11-30 gemini-bringup: Test points on major power rails
2020-11-30 spi-to-ethanol: fix capacitor value typo
2020-11-30 sp-ethernet: set footprint on zero-ohm jumper
2020-11-30 power: use polarized symbol for tantalum cap
2020-11-30 gemini-bringup: mark schematic checklist as completed
2020-11-30 gemini-bringup: forward annotate schematic updates to PCB
2020-11-30 gemini-bringup: connect remaining 3.3V pins on RoT connector
2020-11-30 gemini-bringup: rework ethernet VDDA_3.3V bypass cap layout
2020-12-01 gemini-bringup: incorporate zero-ohm link in STM32H753 high-speed crystal
2020-12-01 gemini-bringup: rework STM32H753 3.3V bypass caps in SW corner of footprint
2020-12-01 gemini-bringup: rework 12V bulk cap and 3.3V regulator output cap
2020-12-01 spi-to-ethanol: remove accidental connection between ~SPI_ROM_PROG and SPI_ROM_MISO
2020-12-01 gemini-bringup: connect additional 3.3V pin on RoT connector
2020-12-01 gemini-bringup: Place power test points
2020-12-01 gemini-bringup: silkscreen cleanups
2020-12-03 fans: update for U701 footprint name change
2020-12-03 sp: move LEDs from STM32H753 PKx to unused pins on PIx to prepare for change to LQFP176
2020-12-05 gemini-bringup: rework layout around STM32H753 due to footprint change
    Change from LQFP208 to LQFP176 kept most signals roughly in the same
    area of the footprint but the density of traces in that area led to a
    nearly complete rework of the area. All nets are routed with the
    following caveats:
    * VCAP1/2 are tied via a fill on the power plane (In2.Cu). SD/eMMC
    DA0/1 currently cross this fill. I'm looking for alternative routes that
2020-12-07 gemini-bringup: dedicated gnd via for HOST_ACCESS pull-down
2020-12-07 gemini-bringup: add bypass caps near SPI6_x reference plane changes
2020-12-07 gemini-bringup: sprinkle caps near dense layer change areas
2020-12-07 misc annotation
2020-12-07 gemini-bringup: move bypass cap near ROT_SCK layer change to back side
2020-12-07 gemini-bringup: tune QSPI trace lengths
2020-12-07 gemini-bringup: tune 100BaseTX trace lengths
2020-12-07 gemini-bringup: tune FPGA_SPI trace lengths
2020-12-07 gemini-bringup: tweak silkscreen for readability
2020-12-07 gemini-bringup: update board identifier footprint
2020-12-07 sp: add CPN for STM32H753IITx
2020-12-07 Run schematic generation on release tags
2020-12-08 Set Company, Title, and P/N on every schematic page
2020-12-08 Correct MPN for CPN 216-00006
2020-12-08 Correct MPN for CPN 216-00007
2020-12-08 fix MPN for CPN 216-00005
2020-12-08 fix MPN for CPN 216-00004
2020-12-10 KiBOM config for Sierra Circuits friendly BOM generation
2020-12-10 lpc55_carrier: set default silkscreen size and thickness to Sierra Circuits default minimums
2020-12-10 Tag as revision 1
    * Set schematic issue date to 2020-12-07 and Revision to 1
    * Set layout board identifier revision to 1
2020-12-23 Add initial rev1 user guide
2020-12-31 getting started nits, note about J301/J202 being compatible with STDC14
2021-04-21 gimletlet rev1
2021-05-14 gimletlet: fork stm32h7 symbol to fix ERC
2021-05-28 gimletlet: PDFs and mechanical drawings
2021-05-28 doc/gimletlet-2: fix lists
2021-07-01 Documentation fixes, add TODOs
2021-07-01 Finish first pass of layout, lots of small fixes
2021-07-01 Add regulator symbols
2021-07-01 Add regulators, power flags, bits of schematic
2021-07-01 Various
    - Simplify power, assume always powered via barrel jack or J2
    - Add operating mode descriptions
    - Rename IGNITION_TARGET_HDR
    - Small visual improvements
2021-07-01 Update pdf
2021-07-02 Add SerDes silkscreen labels
2021-07-03 Extend J16 to allow Type 1 GPIO interface
2021-07-13 Add LVDS SMA adapter, finish programming adapter, Ignitionlet nits
    - Add LVDS SMA adapter for ULX3S/ECP5 EVN boards
    - Finish Ignition Target programming adapter
    - Small nit fixes in Ignitionlet found after tapeout
2021-07-21 Add spimux files sent out for production. Add dimmlet files
2021-07-31 Incorporate rev2 changes due to rework on dimmlet. add gerbers for both spi-mux and dimmlet rev2
2021-08-24 Adding rev2 spimux stuff
2021-09-03 Add R4, R5 rework, thanks rick! Add finished pictures
2021-11-11 Add PNs to Gimletlet for easier Circuithub import
2021-11-30 Add PNs to Gimletlet for easier Circuithub import (#39)
    * Add PNs to Gimletlet for easier Circuithub import
    * Move part-specific details to 'Comment' field for better import
2021-12-20 Add library tables
2022-01-05 clean up commit
2022-01-10 Add Oxide wordmark
2022-01-13 Add MFG and MPN for remaining parts
2022-01-13 Add Gimletlet and NIC2 to Github actions
2022-01-13 Add minor README (to link to review doc)
2022-03-29 Add NRST LED
2022-03-31 Updates to NIC (#44)
    * Updates to NIC
    * Add NRST LED
    * Fix LED colors in BOM
2022-04-01 Tweak README and Actions
2022-04-01 Add badges and links
2022-04-01 Move Ignitionlet to subfolder
2022-04-01 Clean up fp/sym-lib-table to avoid absolute paths
2022-04-01 More README updates
2022-04-05 Update README with adapter
2022-04-06 Quoting from Smart Prototyping
2022-04-27 Update NIC2 readme
2023-02-24 Add MPL license
